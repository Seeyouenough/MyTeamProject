# Keil uVision project FC32_Flight.uvprojx, settings and files
target empty_flight (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: FC32_Flight +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\applications;.\devices;.\drivers;.\lib\inc;.\core;.\obj;..\FC32_Flight;.\misc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group app
    ./applications/: main.c delay.c imu.c imu.h ctrl.c ctrl.h timer.c timer.h sys.c sys.h
  group device
    ./devices/: device_battery_adc.c device_battery_adc.h device_led.c device_led.h device_mpu6050.c device_mpu6050.h device_data_trans.c device_data_trans.h device_pwm.c device_pwm.h device_capture.c device_capture.h
  group driver
    ./drivers/: driver_data_trans.c driver_data_trans.h driver_led.c driver_led.h driver_mpu6050.c driver_mpu6050.h driver_senser_iic.c driver_senser_iic.h
  group libs
    ./lib/src/: misc.c stm32f10x_adc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_i2c.c
  group misc
    ./misc/: stm32f10x_it.c system_stm32f10x.c
    ./core/: startup_stm32f10x_hd.s
  group README
    ./: README.txt
