# Keil uVision project 全向轮.uvprojx, settings and files
target project (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 全向轮 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10x_HD
  c include: .\app;.\devices;.\drivers;.\libs\inc;.\misc;.\obj
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group app
    ./app/: main.c ctrl.c ctrl.h
  group drivers
    ./drivers/: delay.c delay.h led.c led.h pwm.c pwm.h timer.c timer.h speed.c speed.h mpu9250.c mpu9250.h mpuiic.c mpuiic.h imu.c imu.h ultrasound.c ultrasound.h usart.c usart.h flysky.c flysky.h stmflash.c stmflash.h
  group libs
    ./libs/src/: misc.c stm32f10x_adc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
  group misc
    ./misc/: core_cm3.c stm32f10x_it.c sys.c system_stm32f10x.c startup_stm32f10x_hd.s
